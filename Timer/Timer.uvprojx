# Keil uVision project Timer.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.4.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Timer +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Huins_NXP_LPC1768_Library\Drivers\include;..\Huins_NXP_LPC1768_Library\Core\Device\NXP\LPC17xx\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Drivers
    ./: timer.c timer2.c timer3.c
    ../Huins_NXP_LPC1768_Library/Drivers/source/: lpc17xx_exti.c lpc17xx_gpio.c lpc17xx_nvic.c lpc17xx_timer.c LPC1768_fnd.c LPC1768_utility.c lpc17xx_libcfg_default.c lpc17xx_pinsel.c lpc17xx_clkpwr.c
software components: Device:Startup 1.0.0
